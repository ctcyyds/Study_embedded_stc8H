# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USB
  group Source Group 1
    ./: main.c GPIO.c STC8xxxx.H
  group USB
    ./USB/: timer.c usb.c usb_desc.c usb_req_class.c usb_req_std.c usb_req_vendor.c util.c stc.h timer.h usb.h usb_desc.h usb_req_class.h usb_req_std.h usb_req_vendor.h util.h usb_config.h
